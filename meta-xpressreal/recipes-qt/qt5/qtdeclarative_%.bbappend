PACKAGECONFIG:append = " examples"

