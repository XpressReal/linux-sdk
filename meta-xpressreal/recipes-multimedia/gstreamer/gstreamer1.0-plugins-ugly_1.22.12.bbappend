PACKAGECONFIG:append:pn-gstreamer1.0-plugins-ugly = " x264"
