SUMMARY = "PyOTP - Python One-Time Password Library"
HOMEPAGE = "https://github.com/pyauth/pyotp"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f4889ab24aecac0a410d83c0323f9daf"

SRC_URI[sha256sum] = "346b6642e0dbdde3b4ff5a930b664ca82abfa116356ed48cc42c7d6590d36f63"

inherit pypi setuptools3
