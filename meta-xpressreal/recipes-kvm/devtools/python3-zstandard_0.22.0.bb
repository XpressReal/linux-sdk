SUMMARY = "Zstandard bindings for Python"
HOMEPAGE = "https://pypi.org/project/zstandard/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3ae87c50fd64b6f0942823686871e758"

inherit pypi setuptools3

SRC_URI[sha256sum] = "8226a33c542bcb54cd6bd0a366067b610b41713b64c9abec1bc4533d69f51e70"

PYPI_PACKAGE = "zstandard"
