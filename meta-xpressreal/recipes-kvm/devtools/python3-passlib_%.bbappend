FILESEXTRAPATHS:prepend := "${THISDIR}/files:"


SRC_URI += " file://0001-use-version-instead-of-about-version.patch"
