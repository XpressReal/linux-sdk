IMAGE_INSTALL:append = " \
		libdrm libdrm-tests \
		glmark2 \
		mesa-demos \
		fontconfig \
		"
